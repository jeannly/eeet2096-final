# Keil uVision project STM32F439_Template.uvprojx, settings and files
target STM32F4 RAM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F439IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F439_Template
  c flags: Optim=1 uC99=1
  c define: DAUGHTER_REV1 STM32F439
  c include: .\inc;.\inc\CMSIS;.\RTE\Device\STM32F439IITx
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./src/: stm32f4xx_it.c boardSupport.c gpioControl.c acSystem.c lightSystem.c main.c peripherals.c
  group Headers
    ./inc/: config.h boardSupport.h stm32f439xx.h ioMapping.h gpioControl.h acSystem.h lightSystem.h peripherals.h
    ./RTE/Device/STM32F439IITx/: system_stm32f4xx.h
target STM32F4 FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F439IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: STM32F439_Template
  c flags: Optim=1
  c define: DAUGHTER_REV1 STM32F439
  c include: .\inc;.\inc\CMSIS;.\RTE\Device\STM32F439IITx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.1.1, Device:Startup 2.6.2
